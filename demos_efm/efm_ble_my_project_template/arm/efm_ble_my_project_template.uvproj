# Keil uVision project efm_ble_my_project_template.uvproj, settings and files
target efm_ble_my_project_template (ARM-ADS)
  device: EFM32LG990F256 Energy Micro
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: heart_rate_sensor
  AfterMake: fromelf.exe --bin --output obj\heart_rate_sensor.bin obj\heart_rate_sensor.axf
  c flags: Optim=1
  c define: EFM32LG990F256 DEBUG_EFM __EFM32__
  c misc: --c99
  c include: ..\;..\..\efm_common_libs\common_inc;..\..\efm_common_libs\common_inc\config;..\..\efm_common_libs\bsp\inc;..\..\efm_common_libs\emlib\inc;..\..\efm_common_libs\CMSIS\inc;..\..\efm_common_libs\drivers\inc;..\..\..\libraries\BLE;..\efm_ble_my_project_template_inc
  asm include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\EnergyMicro\EFM32LG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\bsp;..\..\..\config;..\efm_ble_my_project_template_inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../efm_common_libs/CMSIS/src/: system_efm32lg.c startup_efm32lg.s
  group bsp
    ../../efm_common_libs/bsp/src/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
  group emlib
    ../../efm_common_libs/emlib/src/: em_assert.c em_cmu.c em_ebi.c em_emu.c em_gpio.c em_int.c em_lcd.c em_system.c em_usart.c
  group drivers
    ../../efm_common_libs/drivers/src/: segmentlcd.c
  group Source
    ../: main.c
  group BLE
    ../../../libraries/BLE/: aci_queue.cpp aci_setup.cpp acilib.cpp hal_aci_tl.cpp hal_platform.cpp lib_aci.cpp
